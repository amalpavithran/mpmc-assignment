ORG 0
	//DELAY = 0.1ms
	//FREQUENCY RANGE 1HZ to 10000HZ
	MOV TMOD,#51H
	SETB P3.5
	START:
		MOV TH1,#00H
		MOV TL1,#00H
		SETB TR1
		ACALL DELAY
		SJMP START
		
		DELAY:
			MOV R0,#16
			HERE2:MOV TH0,#0
			MOV TL0,#0
			SETB TR0
			HERE: JNB TF0,HERE
			CLR TF1
			DJNZ R0,HERE2
			CLR TR0
			CLR TR1
			MOV A,TL1
			MOV P2,A
			MOV A,TH1
			MOV P1,A
			RET
 END